<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\247-637 S-0001 V7.ewp</path>
  </project>
  <batchBuild />
</workspace>
